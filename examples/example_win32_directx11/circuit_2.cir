Empty walls

VD 1 0  1
R1 1 2 1e3
D1 2 0 0
